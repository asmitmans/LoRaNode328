File: MCU.kicad_sch (KiCad schematic)
At the start: 10 parts, among them U2 ATmega328P-A, Y2 8MHz

Commit message: LoRa Scheme
Connections:
- net Earth renamed GND
- net VCC renamed MCU_3V3
